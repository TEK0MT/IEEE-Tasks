#include <assert.h>
#include <ctype.h>
#include <limits.h>
#include <math.h>
#include <stdbool.h>
#include <stddef.h>
#include <stdint.h>
#include <stdio.h>
#include <stdlib.h>
#include <string.h>

char* readline();
char* ltrim(char*);
char* rtrim(char*);

int parse_int(char*);

/*
 * Complete the 'isBalanced' function below.
 *
 * The function is expected to return a STRING.
 * The function accepts STRING s as parameter.
 */

/*
 * To return the string from the function, you should either do static allocation or dynamic allocation
 *
 * For example,
 * char* return_string_using_static_allocation() {
 *     static char s[] = "static allocation of string";
 *
 *     return s;
 * }
 *
 * char* return_string_using_dynamic_allocation() {
 *     char* s = malloc(100 * sizeof(char));
 *
 *     s = "dynamic allocation of string";
 *
 *     return s;
 * }
 *
 */
/***********************************************************************************************/
 typedef struct 
 {
     void **Array;
    signed int Top;
 }stack;
 stack* CreatStack(int size)
 {
     stack *s = (stack *)malloc(sizeof(stack));
     s->Array = (void **)malloc(size * sizeof(void*));
     s->Top = 0;
     return s;
 }
 void push(stack *s,char data)
 {
     s->Top++;
     s->Array[s->Top - 1] = data;
 }
 void pop(stack *s)
 {
     s->Top--;
 }
char* isBalanced(char* s) {
    int size = strlen(s);
    int flag = 0;
    stack *k = CreatStack(size);
    char* res = (char *)malloc(100 * sizeof(char));
    for(int i = 0;i < strlen(s) ;i++)
    {
        if(s[i] == 40 || s[i] == 91 || s[i] == 123 )
        {
            push(k,s[i]);
        }
        else if(s[i] == (k->Array[k->Top - 1]) + 1 || s[i] == (k->Array[k->Top - 1]) + 2)
        {
            pop(k);
        }
        else 
        {
            flag++;
        }
    }
    if(k ->Top == 0 && flag == 0)
    {
        res = "YES";
    }
    else {
    res = "NO";
    }
    return res;
}
/*************************************************************************************************************************/

int main()
{
    FILE* fptr = fopen(getenv("OUTPUT_PATH"), "w");

    int t = parse_int(ltrim(rtrim(readline())));

    for (int t_itr = 0; t_itr < t; t_itr++) {
        char* s = readline();

        char* result = isBalanced(s);

        fprintf(fptr, "%s\n", result);
    }

    fclose(fptr);

    return 0;
}

char* readline() {
    size_t alloc_length = 1024;
    size_t data_length = 0;

    char* data = malloc(alloc_length);

    while (true) {
        char* cursor = data + data_length;
        char* line = fgets(cursor, alloc_length - data_length, stdin);

        if (!line) {
            break;
        }

        data_length += strlen(cursor);

        if (data_length < alloc_length - 1 || data[data_length - 1] == '\n') {
            break;
        }

        alloc_length <<= 1;

        data = realloc(data, alloc_length);

        if (!data) {
            data = '\0';

            break;
        }
    }

    if (data[data_length - 1] == '\n') {
        data[data_length - 1] = '\0';

        data = realloc(data, data_length);

        if (!data) {
            data = '\0';
        }
    } else {
        data = realloc(data, data_length + 1);

        if (!data) {
            data = '\0';
        } else {
            data[data_length] = '\0';
        }
    }

    return data;
}

char* ltrim(char* str) {
    if (!str) {
        return '\0';
    }

    if (!*str) {
        return str;
    }

    while (*str != '\0' && isspace(*str)) {
        str++;
    }

    return str;
}

char* rtrim(char* str) {
    if (!str) {
        return '\0';
    }

    if (!*str) {
        return str;
    }

    char* end = str + strlen(str) - 1;

    while (end >= str && isspace(*end)) {
        end--;
    }

    *(end + 1) = '\0';

    return str;
}

int parse_int(char* str) {
    char* endptr;
    int value = strtol(str, &endptr, 10);

    if (endptr == str || *endptr != '\0') {
        exit(EXIT_FAILURE);
    }

    return value;
}
